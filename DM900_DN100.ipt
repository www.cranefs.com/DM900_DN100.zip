# Autodesk Inventor part: DM900_DN100
## iProperties
Created: 2010-12
Part Number: DM900_DN100
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
